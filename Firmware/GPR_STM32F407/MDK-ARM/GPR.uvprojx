# Keil uVision project GPR.uvprojx, settings and files
target GPR (6210000::V6.21::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GPR
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ./: main_app.c VCO.c gui.c
    ../Src/: functions.c ADF4351.c AD8302.c main.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c AD9910.c ILI9341.c XPT2046.c W25Q.c mathematics.c windows.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_gpio.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.6.0, RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, Compiler:I/O:STDOUT 1.2.0, LVGL:lvgl:Essential 8.3.7, LVGL:lvgl:Extra Themes 8.3.7
